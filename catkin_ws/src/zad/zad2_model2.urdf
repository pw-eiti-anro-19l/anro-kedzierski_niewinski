Commit message: dziala kdl

File: catkin_ws/src/zad/zad2_model2.urdf (robot description, URDF)
Before this commit: robot zad2, 4 links, 3 joints
Joints:
- joint joint3: axis 1 0 0 -> -1 0 0
